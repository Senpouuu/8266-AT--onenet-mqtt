# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\RT-Thread;.\RT-Thread\include;.\RT-Thread\include\libc;.\fwlib\inc;.\mcu_fun\inc;.\driver\inc;.\hardware\inc;.\applications;.\NET\net_task;.\NET\MQTT;.\NET\onenet\inc;.\NET\device\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group RT-Thread
    ./RT-Thread/cortex-M3/: context_rvds.S cpuport.c
    ./RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_iwdg.c stm32f10x_i2c.c
  group mcu_fun
    ./mcu_fun/src/: mcu_adc.c mcu_dma.c mcu_exti.c mcu_gpio.c mcu_nvic.c mcu_rcc.c mcu_spi.c mcu_timer.c mcu_usart.c mcu_i2c.c
  group driver
    ./driver/src/: adc.c delay.c hwtimer.c i2c.c iwdg.c rtc.c spi.c usart.c
  group hardware
    ./hardware/src/: ADXL362.c at24c02.c beep.c info.c ir.c key.c lcd1602.c led.c light.c nec.c sht20.c spilcd.c
  group applications
    ./applications/: application.c startup.c FONT.c
    ./RT-Thread/: board.c rtconfig.h
  group net_task
    ./NET/net_task/: net_task.c
  group onenet
    ./NET/onenet/src/: cmd_callback.c dStream.c onenet.c
  group net_device
    ./NET/device/src/: net_device.c net_io.c
software components: CMSIS:CORE 4.3.0
